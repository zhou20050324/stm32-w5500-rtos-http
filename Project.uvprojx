# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Start;.\User;.\Library;.\Hardware;.\System;.\Ethernet;.\Ethernet\W5500;.\SensorCollection;.\Web;.\Web\httpServer;.\freeRTOS\include;.\freeRTOS\portable;.\freeRTOS\source;.\RTOS_application;.\freeRTOS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
  group Hardware
    ./Hardware/: Key.c Key.h LED.c LED.h OLED.c OLED.h OLED_Font.h SPI1.c UART1.c timer3.c
  group System
    ./System/: Delay.c Delay.h
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Ethernet
    ./Ethernet/: eth.c socket.c wizchip_conf.c
    ./Ethernet/W5500/: w5500.c
  group Library
    ./Library/: stm32f10x_wwdg.h stm32f10x_wwdg.c stm32f10x_usart.h stm32f10x_usart.c stm32f10x_tim.h stm32f10x_tim.c stm32f10x_spi.h stm32f10x_spi.c stm32f10x_sdio.h stm32f10x_sdio.c stm32f10x_rtc.h stm32f10x_rtc.c stm32f10x_rcc.h stm32f10x_rcc.c stm32f10x_pwr.h stm32f10x_pwr.c stm32f10x_iwdg.h stm32f10x_iwdg.c stm32f10x_i2c.h stm32f10x_i2c.c stm32f10x_gpio.h stm32f10x_gpio.c stm32f10x_fsmc.h stm32f10x_fsmc.c stm32f10x_flash.h stm32f10x_flash.c stm32f10x_exti.h stm32f10x_exti.c stm32f10x_dma.h stm32f10x_dma.c stm32f10x_dbgmcu.h stm32f10x_dbgmcu.c stm32f10x_dac.h stm32f10x_dac.c stm32f10x_crc.h stm32f10x_crc.c stm32f10x_cec.h stm32f10x_cec.c stm32f10x_can.h stm32f10x_can.c stm32f10x_bkp.h stm32f10x_bkp.c stm32f10x_adc.h stm32f10x_adc.c misc.h misc.c
  group SensorCollection
    ./SensorCollection/: adc.c dht11.c
  group RTOS_application
    ./RTOS_application/: APP_freeRTOS.c
  group freeRTOS
    ./freeRTOS/: FreeRTOSConfig.h
  group freeRTOS/source
    ./freeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freeRTOS/include
    ./freeRTOS/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freeRTOS/portable
    ./freeRTOS/portable/: heap_4.c port.c
